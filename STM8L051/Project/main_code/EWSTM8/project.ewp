# IAR project project.ewp, settings and files
configuration STM8L05X_LD_VL(STM8L05xx3) (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_STM8L1526_EVAL; STM8L05X_LD_VL
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM8_EVAL; ..\..\..\Utilities\STM8_EVAL\STM8L1526_EVAL; ..\..\..\Utilities\STM8_EVAL\Common; ..\..\..\Utilities\Misc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration relase (STM8)
  as the first configuration, except:
  General.GenCodeModel: 1
  group User
    ../: cc1101.c main.c stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
  group User/STM8L15x_StdPeriph_Driver
    ../../../Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_wwdg.c
