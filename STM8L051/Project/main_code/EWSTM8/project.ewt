<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>STM8L05X_LD_VL(STM8L05xx3)</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>relase</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>User</name>
    <group>
      <name>STM8L15x_StdPeriph_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM8L15x_StdPeriph_Driver\src\stm8l15x_clk.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM8L15x_StdPeriph_Driver\src\stm8l15x_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM8L15x_StdPeriph_Driver\src\stm8l15x_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM8L15x_StdPeriph_Driver\src\stm8l15x_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM8L15x_StdPeriph_Driver\src\stm8l15x_itc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM8L15x_StdPeriph_Driver\src\stm8l15x_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM8L15x_StdPeriph_Driver\src\stm8l15x_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM8L15x_StdPeriph_Driver\src\stm8l15x_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM8L15x_StdPeriph_Driver\src\stm8l15x_wwdg.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\cc1101.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\stm8l15x_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\stm8l15x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\stm8l15x_it.h</name>
    </file>
  </group>
</project>


